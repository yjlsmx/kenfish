# Keil uVision project STM32_FreeRTOS_User.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_FreeRTOS +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ./Objects/@L.bin  ./Objects/@L.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\kernel\include;..\STM32F10xFWLib_v3.5.0\inc;..\Common;..\CM3;..\User;..\..\Include
  memory RVCT4: ROM 0x8008000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group kernel
    ../kernel/: heap_2.c list.c port.c queue.c tasks.c
  group user
    ../User/: CPGCore.c SmartTuna.c LMST_MotionCtrl.c LM_queue_m3_FreeRtos.c LM_Uudp.c LM_Cudp_m3.c LMST_Pwm.c LM_SystemClock.c LM_Common.c cJSON.c OnChip.c LMST_TailNode.c LMST_ServoMotorNode.c LMST_HeadNode.c LMST_NodeCommon.c LM_BatteryManager.c LMST_SensorNode.c LMST_HeadNode_LocalCtrl.c LM_BuoyantDevices.c LMST_DivingNode.c LM_Timer.c LM_Ahrs.c LM_Dcm.c LM_Bmp180.c LM_IIC.c
  group FWLib
    ../STM32F10xFWLib_v3.5.0/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group doc
    ../doc/: log.txt
  group common
    ../Common/: cortexm3_macro_rvds.s STM32F10x.s
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
